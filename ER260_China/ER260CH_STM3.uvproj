# Keil uVision project ER260CH_STM3.uvproj, settings and files
target ER220CH (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: aER220CH_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER220,CASE_FORHANZI
  c include: ..\STM32Driver\USER\inc;.\EosCLCD;..\STM32Driver\Print;..\STM32Driver\USER;..\STM32Driver\Utilities\USB_APP\inc;..\STM32Driver\Utilities\Third_Party\fat_fs\inc;..\STM32Driver\Libraries\STM32_USB_Device_Library\Core\inc;..\STM32Driver\Libraries\STM32_USB_HOST_Library\Core\inc;..\STM32Driver\Libraries\STM32_USB_Device_Library\Class\MSC\inc;..\STM32Driver\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\STM32Driver\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\STM32Driver\Libraries\STM32_USB_OTG_Driver\inc;..\STM32Driver\Utilities\STM32_EVAL\STM322xG_EVAL;..\STM32Driver\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\STM32Driver\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
  group USER
    ../STM32Driver/USER/: stm32f2xx_it.c usart.c fsmc_sram.c spi_m25p80.c KeyBoard.c interface.c sdio_sd.c asciifonts.c lcd_st7565r.c led_customer.c pwr_ctrl.c monitor.c flashb.c USB_Application.c ECR_IAP.c
  group APP
    ./EOSCLCD/: Timer.c Chinaapp.c CHNDisp.c CHNInput.c CHNMess.c Clerk.c Computer.c Correc.c Currency.c Depart.c Discount.c Drawer.c ePOSCard.c ExtModules.c Firmkey.c Fiscal.c Fixed.c Flowbill.c Format.c General.c Gprs.c Group.c Hardtest.c ICCard.c ICCardBlock.c Initappl.c Kp.c Main.c MEMORY.c Modifier.c OFFPrice.c Pb.c Pbbuffer.c Plu.c Pora.c Port.c Print.c Progdump.c Progopt.c Program.c Report2.c Report.c Salper.c Search.c Tax.c Tender.c PyCode.c Buffer.c Agree.c Balance.c Barcode.c Menu.c USBDiskApp.c SysTick.c QR_Encode.c EJournal.c
  group Printer
    ../STM32Driver/Print/: Print_Main.c Print_DEF.c
  group STM32Driver
    ../STM32Driver/: aSTM32Driver.lib
target ER260CH (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260CH_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_FORHANZI
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260EN (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260EN_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER220EN (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER220EN_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER220
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260SP (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260SP_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_SPANISH
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260_DEBUG (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: ER260CH_DEBUG +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,FOR_DEBUG,CASE_EJFLASH,CASE_PERU
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER520CH (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER520CH_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER520U,DD_LOCK,CASE_FORHANZI
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER520EN (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER520EN_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER520U,DD_LOCK
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER520SP (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER520SP_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER520U,DD_LOCK,CASE_SPANISH
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260VN (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260VN_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_VIETNAM
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260IND_GPRS (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260INDONESIA_GPRS_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_INDONESIA,CASE_GPRS
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260INDIA_xGPRS (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260INDIA_xGPRS_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_INDONESIA,CASE_INDIA
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260PERU_EJFLASH (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260PERU_EJFLASH +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_SPANISH,CASE_EJFLASH,CASE_PERU
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
