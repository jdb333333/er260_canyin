# Keil uVision project ER260CH_NET_STM3.uvproj, settings and files
target ER220CH (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: aER220CH_NET_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER220,CASE_FORHANZI,CASE_ETHERNET
  c include: ..\STM32Driver\USER\inc;.\EosCLCD;..\STM32Driver\Print;..\STM32Driver\USER;..\STM32Driver\Utilities\USB_APP\inc;..\STM32Driver\Utilities\Third_Party\fat_fs\inc;..\STM32Driver\Libraries\STM32_USB_Device_Library\Core\inc;..\STM32Driver\Libraries\STM32_USB_HOST_Library\Core\inc;..\STM32Driver\Libraries\STM32_USB_Device_Library\Class\MSC\inc;..\STM32Driver\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\STM32Driver\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\STM32Driver\Libraries\STM32_USB_OTG_Driver\inc;..\STM32Driver\Utilities\STM32_EVAL\STM322xG_EVAL;..\STM32Driver\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\STM32Driver\Libraries\CMSIS\Include;..\STM32Driver\Utilities\Third_Party\lwip-1.3.2;..\STM32Driver\Utilities\Third_Party\lwip-1.3.2\src\include;..\STM32Driver\Utilities\Third_Party\lwip-1.3.2\src\include\ipv4;..\STM32Driver\Utilities\Third_Party\lwip-1.3.2\src\include\lwip;..\STM32Driver\Utilities\Third_Party\lwip-1.3.2\src\include\netif;..\STM32Driver\NET_enc28j60\inc;.\EOSTCPIP\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
  group USER
    ../STM32Driver/USER/: stm32f2xx_it.c usart.c fsmc_sram.c spi_m25p80.c KeyBoard.c interface.c sdio_sd.c asciifonts.c lcd_st7565r.c led_customer.c pwr_ctrl.c monitor.c flashb.c USB_Application.c ECR_IAP.c
  group CMSIS
    ../STM32Driver/Libraries/CMSIS/: system_stm32f2xx.c startup_stm32f2xx.s
  group STM32F2xx_StdPeriph_Driver
    ../STM32Driver/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group APP
    ./EOSCLCD/: Timer.c Chinaapp.c CHNDisp.c CHNInput.c CHNMess.c Clerk.c Computer.c Correc.c Currency.c Depart.c Discount.c Drawer.c ePOSCard.c ExtModules.c Firmkey.c Fiscal.c Fixed.c Flowbill.c Format.c General.c Gprs.c Group.c Hardtest.c ICCard.c ICCardBlock.c Initappl.c Kp.c Main.c MEMORY.c Modifier.c OFFPrice.c Pb.c Pbbuffer.c Plu.c Pora.c Port.c Print.c Progdump.c Progopt.c Program.c Report2.c Report.c Salper.c Search.c Tax.c Tender.c PyCode.c Buffer.c Agree.c Balance.c Barcode.c Menu.c USBDiskApp.c SysTick.c
  group Printer
    ../STM32Driver/Print/: Print_Main.c Photo_abbigl.c Photo_appetito.c Photo_caffe.c Photo_carneval.c Photo_cornetto.c Photo_cucina.c Photo_donna.c Photo_eutron.c Photo_fiori.c Photo_gelato.c Photo_jolly.c Photo_mamma.c Photo_natale.c Photo_pane.c Photo_papa.c Photo_pasqua.c Photo_pesce.c Photo_risparmi.c Photo_salumi.c Photo_selfdef.c Photo_sport.c Photo_vacanze.c Photo_valentin.c Print_DEF.c Photo_panama.c
  group USB_APP
    ../STM32Driver/Utilities/USB_APP/: usbd_desc.c usbd_storage_msd.c usbd_usr.c usbh_msc_usr.c usb_bsp.c
  group FatFS
    ../STM32Driver/Utilities/Third_Party/fat_fs/src/: ff.c
    ../STM32Driver/Utilities/Third_Party/fat_fs/src/option/: ccsbcs.c
  group USB Driver
    ../STM32Driver/Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c usb_dcd_int.c usb_dcd.c
  group USB Device
    ../STM32Driver/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../STM32Driver/Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_scsi.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c
  group USB Host
    ../STM32Driver/Libraries/STM32_USB_HOST_Library/Core/src/: usbh_ioreq.c usbh_hcs.c usbh_core.c usbh_stdreq.c
    ../STM32Driver/Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_mouse.c usbh_hid_keybd.c usbh_hid_core.c
    ../STM32Driver/Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group LWIP
    ../STM32Driver/Utilities/Third_Party/lwip-1.3.2/src/netif/: etharp.c ethernetif.c slipif.c loopif.c
    ../STM32Driver/Utilities/Third_Party/lwip-1.3.2/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../STM32Driver/Utilities/Third_Party/lwip-1.3.2/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
    ../STM32Driver/Utilities/Third_Party/lwip-1.3.2/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../STM32Driver/Utilities/Third_Party/lwip-1.3.2/ARCH/: sys_arch.C
  group NET_ENC28J60
    ../STM32Driver/NET_enc28j60/: spi_enc28j60.c enc28j60.c netconfig.c
  group TCP_UDP
    ./EOSTCPIP/: udp_server.c tcp_server.c
target ER260CH (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260CH_NET_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_FORHANZI,CASE_ETHERNET
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260EN (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260EN_NET_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_ETHERNET
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER220EN (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER220EN_NET_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER220,CASE_ETHERNET
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260SP (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER260SP_NET_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_SPANISH,CASE_ETHERNET
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER260_DEBUG (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: ER260CH_NET_DEBUG +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260,CASE_FORHANZI,FOR_DEBUG,CASE_ETHERNET
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER520CH (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER520CH_NET_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER520U,DD_LOCK,CASE_FORHANZI,CASE_ETHERNET
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER520EN (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER520EN_NET_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER520U,DD_LOCK,CASE_ETHERNET
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
target ER520SP (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: as above
  output: aER520SP_NET_uSTM3 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER520U,DD_LOCK,CASE_SPANISH,CASE_ETHERNET
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x64000000 size 0x80000
